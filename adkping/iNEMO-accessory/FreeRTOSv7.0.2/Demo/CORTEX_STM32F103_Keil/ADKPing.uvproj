# Keil uVision project ADKPing.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADKPing
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;..\Common\include;..\..\Source\include;.\STM32F10xFWLib\inc;.\USB_Host_Shield;.\AndroidAccessory
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s inemoutil.c
    ../Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c
  group Demo Files
    ./serial/: serial.c
    ./USB_Host_Shield/: Max3421e.c Usb.c
    ./AndroidAccessory/: AndroidAccessory.c
    ./: adkping.c
  group FreeRTOS files
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
